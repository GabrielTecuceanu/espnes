## sdkconfig.defaults
```kconfig
CONFIG_LV_FONT_MONTSERRAT_10=y
CONFIG_LV_FONT_MONTSERRAT_14=y

CONFIG_ESP_MAIN_TASK_STACK_SIZE=32768
```
